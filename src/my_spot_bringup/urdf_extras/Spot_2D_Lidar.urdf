Commit message: Stack tuning

File: src/my_spot_bringup/urdf_extras/Spot_2D_Lidar.urdf (robot description, URDF)
Before this commit: robot spot_extras, 1 links, 1 joints
Joints:
- joint body_to_lidar: origin xyz=0 0 0 rpy=0 0 0 -> xyz=0 0 0.10 rpy=0 0 0
